Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-06-30T10:48:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jun 30 10:48:39 2020 * Host: GVIZITI-RO-DE * Database: C:\Users\gviziti\AppData\Local\Temp\{01598937-3283-4877-907B-3F545B5015D5}\ifc * Database version: 5507 * Database creation date: Tue Jun 30 10:48:36 2020 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Jun 30 10:48:37 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jun 30 10:48:37 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: V00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Constraints(Type) - Elevation Base: Project Base Point

# IfcAirTerminal: MDE 42, VE_Air Heater_MEPcontent_Mark_Tanner MDE_INT-EN:MDE 42:1295568
In: V00
Type - Material: Color RGB 000-000-255, Color RGB 193-193-194, Color RGB 060-060-060
Type - Dimensions - Depth: 440 mm; Height: 570 mm; Width: 660 mm
Type - Electrical - Connection Voltage: 3 x 400V+N+PE; Voltage: 400 V
Type - Electrical - Loads - Power: 42000 W
Type - Identity Data - Article Description: Suspended electric air heater; Article Type: MDE 42; Base Family Version: 12.16; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Suspended electric air heater; EMCS Version: 4.0; ETIM Article Class: EC011330; Family Version: 12.10; GLN: 8719333004471; GTIN: 8720211951206; Manufacturer: Mark Climate Technology; Manufacturer Art. No.: 5017014; Manufacturer URL: https://www.markclimate.com/air-heating/electric-air-heaters/tanner-mde-2/; MEPcontent Class: AIR_HEATER; Model: MDE 42; OmniClass Number: 23.75.70.17; OmniClass Title: Water Heated and Cooled Terminal Heating and Cooling Units; Product Line: Mark; Revit Version: 2018; Type Name: MDE 42; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 060-060-060; Blue: Color RGB 000-000-255; Grey: Color RGB 193-193-194
Type - Mechanical - Air Flow Rate: 1.23611 m3/s; Fan Type: Axial; Heating Power: 452084; Motor Power: 230 W; Nominal Flow Rate: 0 m3/s; Weight: 36
Type - Other - Category: Mechanical Equipment; Bracket Type: M_Bracket_Suspended_MEPcontent_Mark_Tanner MDE_INT-EN_Shared: MDE 42; Depth Equipment: 300 mm; Distance between Brackets: 390 mm; Family Name: VE_Air Heater_MEPcontent_Mark_Tanner MDE_INT-EN; L: 78 mm; Logo Type: Tanner 24-42; Middle Equipment: 150 mm; Middle Equipment Height: 285 mm; N: 50 mm; P: 205 mm; Width Bolts: 45 mm; Width Logo: 255 mm
Type - Text - Pipe Type Category: M570F
Type - Visibility - Back Clearance: 400 mm; Blades for Tanner MDE 12-15: no; Blades for Tanner MDE 24-42: yes; Blades for Tanner MDE 51: no; Blades for Tanner MDE 6-9: no; Tanner MDE 12-15: no; Tanner MDE 24-30: yes; Tanner MDE 42: yes; Tanner MDE 51: no; Tanner MDE 6-9: no
Type - Pset_AirTerminalTypeCommon - Reference: MDE 42
Pset_ManufacturerTypeInformation - Manufacturer: Mark Climate Technology
Constraints - Offset: 0 mm
Dimensions - Area: 9.86121 m2; Volume: 0.12846 m3
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - System Classification: Power
Other - Bottom Clearance Safe: 1800 mm; Family: VE_Air Heater_MEPcontent_Mark_Tanner MDE_INT-EN: MDE 42; Family and Type: VE_Air Heater_MEPcontent_Mark_Tanner MDE_INT-EN: MDE 42; Front Clearance Safe: 490 mm; Left Clearance Safe: 500 mm; Logo Height: 485 mm; Pendant Length Safe: 200 mm; Pendant Visible: yes; Right Clearance Safe: 300 mm; Suspension Console Offset: 0 mm; Top Clearance Safe: 300 mm; Type: VE_Air Heater_MEPcontent_Mark_Tanner MDE_INT-EN: MDE 42; Type Id: VE_Air Heater_MEPcontent_Mark_Tanner MDE_INT-EN: MDE 42; Vertical Offset: 200 mm
Phasing - Phase Created: 3. New Construction
Visibility - Bottom Clearance: 1800 mm; Front Clearance: 490 mm; Left Clearance: 500 mm; Pendant Length: 0 mm; Right Clearance: 300 mm; Service Space: no; Suspension Console: no; Top Clearance: 300 mm
